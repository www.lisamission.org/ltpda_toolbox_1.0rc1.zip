simulink library "ltpda_library"  (Simulink 7.1)
(part 2 of 3)

== system ltpda_library/Methods/ao/Helper/isfield ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  isfield : M-S-Function  Tag=isfield  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> isfield/1
  isfield/1 -> Out1/1

== system ltpda_library/Methods/ao/Helper/isvalid ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  isvalid : M-S-Function  Tag=isvalid  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> isvalid/1
  isvalid/1 -> Out1/1

== system ltpda_library/Methods/ao/Helper/len ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  len : M-S-Function  Tag=len  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> len/1
  len/1 -> Out1/1

== system ltpda_library/Methods/ao/Helper/md5 ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  md5 : M-S-Function  Tag=md5  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> md5/1
  md5/1 -> Out1/1

== system ltpda_library/Methods/ao/Helper/set ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  set : M-S-Function  Tag=set  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> set/1
  set/1 -> Out1/1

== system ltpda_library/Methods/ao/Helper/setnh ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  setnh : M-S-Function  Tag=setnh  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> setnh/1
  setnh/1 -> Out1/1

== system ltpda_library/Methods/ao/Helper/string ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  string : M-S-Function  Tag=string  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> string/1
  string/1 -> Out1/1

== system ltpda_library/Methods/ao/Helper/timeshift ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  timeshift : M-S-Function  Tag=timeshift  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> timeshift/1
  timeshift/1 -> Out1/1

== system ltpda_library/Methods/ao/Helper/validate ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  validate : M-S-Function  Tag=validate  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> validate/1
  validate/1 -> Out1/1

== system ltpda_library/Methods/ao/Operator/abs ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  abs : M-S-Function  Tag=abs  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> abs/1
  abs/1 -> Out1/1

== system ltpda_library/Methods/ao/Operator/complex ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  complex : M-S-Function  Tag=complex  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> complex/1
  complex/1 -> Out1/1

== system ltpda_library/Methods/ao/Operator/conj ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  conj : M-S-Function  Tag=conj  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> conj/1
  conj/1 -> Out1/1

== system ltpda_library/Methods/ao/Operator/ctranspose ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  ctranspose : M-S-Function  Tag=ctranspose  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> ctranspose/1
  ctranspose/1 -> Out1/1

== system ltpda_library/Methods/ao/Operator/det ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  det : M-S-Function  Tag=det  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> det/1
  det/1 -> Out1/1

== system ltpda_library/Methods/ao/Operator/diag ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  diag : M-S-Function  Tag=diag  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> diag/1
  diag/1 -> Out1/1

== system ltpda_library/Methods/ao/Operator/eig ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  eig : M-S-Function  Tag=eig  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> eig/1
  eig/1 -> Out1/1

== system ltpda_library/Methods/ao/Operator/imag ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  imag : M-S-Function  Tag=imag  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> imag/1
  imag/1 -> Out1/1

== system ltpda_library/Methods/ao/Operator/index ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  index : M-S-Function  Tag=index  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> index/1
  index/1 -> Out1/1

== system ltpda_library/Methods/ao/Operator/inv ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  inv : M-S-Function  Tag=inv  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> inv/1
  inv/1 -> Out1/1

== system ltpda_library/Methods/ao/Operator/ln ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  ln : M-S-Function  Tag=ln  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> ln/1
  ln/1 -> Out1/1

== system ltpda_library/Methods/ao/Operator/log ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  log : M-S-Function  Tag=log  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> log/1
  log/1 -> Out1/1

== system ltpda_library/Methods/ao/Operator/log10 ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  log10 : M-S-Function  Tag=log10  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> log10/1
  log10/1 -> Out1/1

== system ltpda_library/Methods/ao/Operator/mean ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  mean : M-S-Function  Tag=mean  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> mean/1
  mean/1 -> Out1/1

== system ltpda_library/Methods/ao/Operator/median ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  median : M-S-Function  Tag=median  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> median/1
  median/1 -> Out1/1

== system ltpda_library/Methods/ao/Operator/mux ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  mux : M-S-Function  Tag=mux  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> mux/1
  mux/1 -> Out1/1

== system ltpda_library/Methods/ao/Operator/norm ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  norm : M-S-Function  Tag=norm  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> norm/1
  norm/1 -> Out1/1

== system ltpda_library/Methods/ao/Operator/phase ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  phase : M-S-Function  Tag=phase  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> phase/1
  phase/1 -> Out1/1

== system ltpda_library/Methods/ao/Operator/real ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  real : M-S-Function  Tag=real  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> real/1
  real/1 -> Out1/1

== system ltpda_library/Methods/ao/Operator/sin ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  sin : M-S-Function  Tag=sin  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> sin/1
  sin/1 -> Out1/1

== system ltpda_library/Methods/ao/Operator/sqrt ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  sqrt : M-S-Function  Tag=sqrt  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> sqrt/1
  sqrt/1 -> Out1/1

== system ltpda_library/Methods/ao/Operator/std ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  std : M-S-Function  Tag=std  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> std/1
  std/1 -> Out1/1

== system ltpda_library/Methods/ao/Operator/sum ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  sum : M-S-Function  Tag=sum  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> sum/1
  sum/1 -> Out1/1

== system ltpda_library/Methods/ao/Operator/svd ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  svd : M-S-Function  Tag=svd  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> svd/1
  svd/1 -> Out1/1

== system ltpda_library/Methods/ao/Operator/tan ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  tan : M-S-Function  Tag=tan  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> tan/1
  tan/1 -> Out1/1

== system ltpda_library/Methods/ao/Operator/transpose ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  transpose : M-S-Function  Tag=transpose  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> transpose/1
  transpose/1 -> Out1/1

== system ltpda_library/Methods/ao/Operator/var ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  var : M-S-Function  Tag=var  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> var/1
  var/1 -> Out1/1

== system ltpda_library/Methods/ao/Output/ao2m ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  ao2m : M-S-Function  Tag=ao2m  FunctionName=ltpdasim
  wires:
  ao2m/1 -> Terminator/1
  In1/1 -> ao2m/1

== system ltpda_library/Methods/ao/Output/char ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  char : M-S-Function  Tag=char  FunctionName=ltpdasim
  wires:
  char/1 -> Terminator/1
  In1/1 -> char/1

== system ltpda_library/Methods/ao/Output/display ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  display : M-S-Function  Tag=display  FunctionName=ltpdasim
  wires:
  display/1 -> Terminator/1
  In1/1 -> display/1

== system ltpda_library/Methods/ao/Output/export ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  export : M-S-Function  Tag=export  FunctionName=ltpdasim
  wires:
  export/1 -> Terminator/1
  In1/1 -> export/1

== system ltpda_library/Methods/ao/Output/extractm ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  extractm : M-S-Function  Tag=extractm  FunctionName=ltpdasim
  wires:
  extractm/1 -> Terminator/1
  In1/1 -> extractm/1

== system ltpda_library/Methods/ao/Output/extractmdl ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  extractmdl : M-S-Function  Tag=extractmdl  FunctionName=ltpdasim
  wires:
  extractmdl/1 -> Terminator/1
  In1/1 -> extractmdl/1

== system ltpda_library/Methods/ao/Output/iplot ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  iplot : M-S-Function  Tag=iplot  FunctionName=ltpdasim
  wires:
  iplot/1 -> Terminator/1
  In1/1 -> iplot/1

== system ltpda_library/Methods/ao/Output/plot ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  plot : M-S-Function  Tag=plot  FunctionName=ltpdasim
  wires:
  plot/1 -> Terminator/1
  In1/1 -> plot/1

== system ltpda_library/Methods/ao/Output/save ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  save : M-S-Function  Tag=save  FunctionName=ltpdasim
  wires:
  save/1 -> Terminator/1
  In1/1 -> save/1

== system ltpda_library/Methods/ao/Output/stairs ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  stairs : M-S-Function  Tag=stairs  FunctionName=ltpdasim
  wires:
  stairs/1 -> Terminator/1
  In1/1 -> stairs/1

== system ltpda_library/Methods/ao/Relational Operator/eq ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  eq : M-S-Function  Tag=eq  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> eq/1
  eq/1 -> Out1/1

== system ltpda_library/Methods/ao/Relational Operator/ge ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  ge : M-S-Function  Tag=ge  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> ge/1
  ge/1 -> Out1/1

== system ltpda_library/Methods/ao/Relational Operator/gt ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  gt : M-S-Function  Tag=gt  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> gt/1
  gt/1 -> Out1/1

== system ltpda_library/Methods/ao/Relational Operator/le ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  le : M-S-Function  Tag=le  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> le/1
  le/1 -> Out1/1

== system ltpda_library/Methods/ao/Relational Operator/lt ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  lt : M-S-Function  Tag=lt  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> lt/1
  lt/1 -> Out1/1

== system ltpda_library/Methods/ao/Relational Operator/ne ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  ne : M-S-Function  Tag=ne  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> ne/1
  ne/1 -> Out1/1

== system ltpda_library/Methods/ao/Signal Processing/compute ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  compute : M-S-Function  Tag=compute  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> compute/1
  compute/1 -> Out1/1

== system ltpda_library/Methods/ao/Signal Processing/downsample ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  downsample : M-S-Function  Tag=downsample  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> downsample/1
  downsample/1 -> Out1/1

== system ltpda_library/Methods/ao/Signal Processing/fft ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  fft : M-S-Function  Tag=fft  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> fft/1
  fft/1 -> Out1/1

== system ltpda_library/Methods/ao/Signal Processing/filter ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  filter : M-S-Function  Tag=filter  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> filter/1
  filter/1 -> Out1/1

== system ltpda_library/Methods/ao/Signal Processing/filtfilt ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  filtfilt : M-S-Function  Tag=filtfilt  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> filtfilt/1
  filtfilt/1 -> Out1/1

== system ltpda_library/Methods/ao/Signal Processing/hist ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  hist : M-S-Function  Tag=hist  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> hist/1
  hist/1 -> Out1/1

== system ltpda_library/Methods/ao/Signal Processing/interp ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  interp : M-S-Function  Tag=interp  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> interp/1
  interp/1 -> Out1/1

== system ltpda_library/Methods/ao/Signal Processing/polyfit ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  polyfit : M-S-Function  Tag=polyfit  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> polyfit/1
  polyfit/1 -> Out1/1

== system ltpda_library/Methods/ao/Signal Processing/resample ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  resample : M-S-Function  Tag=resample  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> resample/1
  resample/1 -> Out1/1

== system ltpda_library/Methods/ao/Signal Processing/select ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  select : M-S-Function  Tag=select  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> select/1
  select/1 -> Out1/1

== system ltpda_library/Methods/ao/Signal Processing/smoother ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  smoother : M-S-Function  Tag=smoother  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> smoother/1
  smoother/1 -> Out1/1

== system ltpda_library/Methods/ao/Signal Processing/spectrogram ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  spectrogram : M-S-Function  Tag=spectrogram  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> spectrogram/1
  spectrogram/1 -> Out1/1

== system ltpda_library/Methods/ao/Signal Processing/split ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  split : M-S-Function  Tag=split  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> split/1
  split/1 -> Out1/1

== system ltpda_library/Methods/ao/Signal Processing/upsample ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  upsample : M-S-Function  Tag=upsample  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> upsample/1
  upsample/1 -> Out1/1

== system ltpda_library/Methods/ao/Trigonometry/acos ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  acos : M-S-Function  Tag=acos  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> acos/1
  acos/1 -> Out1/1

== system ltpda_library/Methods/ao/Trigonometry/asin ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  asin : M-S-Function  Tag=asin  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> asin/1
  asin/1 -> Out1/1

== system ltpda_library/Methods/ao/Trigonometry/atan ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  atan : M-S-Function  Tag=atan  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> atan/1
  atan/1 -> Out1/1

== system ltpda_library/Methods/ao/Trigonometry/cos ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  cos : M-S-Function  Tag=cos  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> cos/1
  cos/1 -> Out1/1

== system ltpda_library/Methods/ao/Trigonometry/exp ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  exp : M-S-Function  Tag=exp  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> exp/1
  exp/1 -> Out1/1

== system ltpda_library/Methods/cdata/Constructor/cdata ==
  Constant : Constant  OutDataType=sfix(16)  OutScaling=2^0
  cdata : M-S-Function  Tag=cdata  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  Constant/1 -> cdata/1
  cdata/1 -> Out1/1

== system ltpda_library/Methods/cdata/Helper/get ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  get : M-S-Function  Tag=get  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> get/1
  get/1 -> Out1/1

== system ltpda_library/Methods/cdata/Helper/isfield ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  isfield : M-S-Function  Tag=isfield  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> isfield/1
  isfield/1 -> Out1/1

== system ltpda_library/Methods/cdata/Helper/isvalid ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  isvalid : M-S-Function  Tag=isvalid  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> isvalid/1
  isvalid/1 -> Out1/1

== system ltpda_library/Methods/cdata/Helper/set ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  set : M-S-Function  Tag=set  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> set/1
  set/1 -> Out1/1

== system ltpda_library/Methods/cdata/Output/char ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  char : M-S-Function  Tag=char  FunctionName=ltpdasim
  wires:
  char/1 -> Terminator/1
  In1/1 -> char/1

== system ltpda_library/Methods/cdata/Output/display ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  display : M-S-Function  Tag=display  FunctionName=ltpdasim
  wires:
  display/1 -> Terminator/1
  In1/1 -> display/1

== system ltpda_library/Methods/cdata/Output/save ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  save : M-S-Function  Tag=save  FunctionName=ltpdasim
  wires:
  save/1 -> Terminator/1
  In1/1 -> save/1

== system ltpda_library/Methods/cdata/Relational Operator/eq ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  eq : M-S-Function  Tag=eq  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> eq/1
  eq/1 -> Out1/1

== system ltpda_library/Methods/cdata/Relational Operator/ne ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  ne : M-S-Function  Tag=ne  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> ne/1
  ne/1 -> Out1/1

== system ltpda_library/Methods/fsdata/Constructor/fsdata ==
  Constant : Constant  OutDataType=sfix(16)  OutScaling=2^0
  fsdata : M-S-Function  Tag=fsdata  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  Constant/1 -> fsdata/1
  fsdata/1 -> Out1/1

== system ltpda_library/Methods/fsdata/Helper/get ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  get : M-S-Function  Tag=get  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> get/1
  get/1 -> Out1/1

== system ltpda_library/Methods/fsdata/Helper/isfield ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  isfield : M-S-Function  Tag=isfield  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> isfield/1
  isfield/1 -> Out1/1

== system ltpda_library/Methods/fsdata/Helper/isvalid ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  isvalid : M-S-Function  Tag=isvalid  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> isvalid/1
  isvalid/1 -> Out1/1

== system ltpda_library/Methods/fsdata/Helper/set ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  set : M-S-Function  Tag=set  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> set/1
  set/1 -> Out1/1

== system ltpda_library/Methods/fsdata/Output/char ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  char : M-S-Function  Tag=char  FunctionName=ltpdasim
  wires:
  char/1 -> Terminator/1
  In1/1 -> char/1

== system ltpda_library/Methods/fsdata/Output/display ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  display : M-S-Function  Tag=display  FunctionName=ltpdasim
  wires:
  display/1 -> Terminator/1
  In1/1 -> display/1

== system ltpda_library/Methods/fsdata/Output/save ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  save : M-S-Function  Tag=save  FunctionName=ltpdasim
  wires:
  save/1 -> Terminator/1
  In1/1 -> save/1

== system ltpda_library/Methods/fsdata/Relational Operator/eq ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  eq : M-S-Function  Tag=eq  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> eq/1
  eq/1 -> Out1/1

== system ltpda_library/Methods/fsdata/Relational Operator/ne ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  ne : M-S-Function  Tag=ne  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> ne/1
  ne/1 -> Out1/1

== system ltpda_library/Methods/history/Constructor/history ==
  Constant : Constant  OutDataType=sfix(16)  OutScaling=2^0
  history : M-S-Function  Tag=history  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  Constant/1 -> history/1
  history/1 -> Out1/1

== system ltpda_library/Methods/history/Helper/get ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  get : M-S-Function  Tag=get  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> get/1
  get/1 -> Out1/1

== system ltpda_library/Methods/history/Helper/isfield ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  isfield : M-S-Function  Tag=isfield  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> isfield/1
  isfield/1 -> Out1/1

== system ltpda_library/Methods/history/Helper/isvalid ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  isvalid : M-S-Function  Tag=isvalid  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> isvalid/1
  isvalid/1 -> Out1/1

== system ltpda_library/Methods/history/Helper/set ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  set : M-S-Function  Tag=set  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> set/1
  set/1 -> Out1/1

== system ltpda_library/Methods/history/Output/char ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  char : M-S-Function  Tag=char  FunctionName=ltpdasim
  wires:
  char/1 -> Terminator/1
  In1/1 -> char/1

== system ltpda_library/Methods/history/Output/display ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  display : M-S-Function  Tag=display  FunctionName=ltpdasim
  wires:
  display/1 -> Terminator/1
  In1/1 -> display/1

== system ltpda_library/Methods/history/Output/hist2dot ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  hist2dot : M-S-Function  Tag=hist2dot  FunctionName=ltpdasim
  wires:
  hist2dot/1 -> Terminator/1
  In1/1 -> hist2dot/1

== system ltpda_library/Methods/history/Output/plot ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  plot : M-S-Function  Tag=plot  FunctionName=ltpdasim
  wires:
  plot/1 -> Terminator/1
  In1/1 -> plot/1

== system ltpda_library/Methods/history/Output/save ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  save : M-S-Function  Tag=save  FunctionName=ltpdasim
  wires:
  save/1 -> Terminator/1
  In1/1 -> save/1

== system ltpda_library/Methods/history/Output/string ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  string : M-S-Function  Tag=string  FunctionName=ltpdasim
  wires:
  string/1 -> Terminator/1
  In1/1 -> string/1

== system ltpda_library/Methods/history/Relational Operator/eq ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  eq : M-S-Function  Tag=eq  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> eq/1
  eq/1 -> Out1/1

== system ltpda_library/Methods/history/Relational Operator/ne ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  ne : M-S-Function  Tag=ne  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> ne/1
  ne/1 -> Out1/1

== system ltpda_library/Methods/mfir/Constructor/mfir ==
  Constant : Constant  OutDataType=sfix(16)  OutScaling=2^0
  mfir : M-S-Function  Tag=mfir  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  Constant/1 -> mfir/1
  mfir/1 -> Out1/1

== system ltpda_library/Methods/mfir/Helper/get ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  get : M-S-Function  Tag=get  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> get/1
  get/1 -> Out1/1

== system ltpda_library/Methods/mfir/Helper/isfield ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  isfield : M-S-Function  Tag=isfield  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> isfield/1
  isfield/1 -> Out1/1

== system ltpda_library/Methods/mfir/Helper/isvalid ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  isvalid : M-S-Function  Tag=isvalid  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> isvalid/1
  isvalid/1 -> Out1/1

== system ltpda_library/Methods/mfir/Helper/redesign ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  redesign : M-S-Function  Tag=redesign  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> redesign/1
  redesign/1 -> Out1/1

== system ltpda_library/Methods/mfir/Helper/set ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  set : M-S-Function  Tag=set  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> set/1
  set/1 -> Out1/1

== system ltpda_library/Methods/mfir/Helper/string ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  string : M-S-Function  Tag=string  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> string/1
  string/1 -> Out1/1

== system ltpda_library/Methods/mfir/Output/char ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  char : M-S-Function  Tag=char  FunctionName=ltpdasim
  wires:
  char/1 -> Terminator/1
  In1/1 -> char/1

== system ltpda_library/Methods/mfir/Output/display ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  display : M-S-Function  Tag=display  FunctionName=ltpdasim
  wires:
  display/1 -> Terminator/1
  In1/1 -> display/1

== system ltpda_library/Methods/mfir/Output/save ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  save : M-S-Function  Tag=save  FunctionName=ltpdasim
  wires:
  save/1 -> Terminator/1
  In1/1 -> save/1

== system ltpda_library/Methods/mfir/Relational Operator/eq ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  eq : M-S-Function  Tag=eq  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> eq/1
  eq/1 -> Out1/1

== system ltpda_library/Methods/mfir/Relational Operator/ne ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  ne : M-S-Function  Tag=ne  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> ne/1
  ne/1 -> Out1/1

== system ltpda_library/Methods/mfir/Signal Processing/resp ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  resp : M-S-Function  Tag=resp  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> resp/1
  resp/1 -> Out1/1

== system ltpda_library/Methods/miir/Constructor/miir ==
  Constant : Constant  OutDataType=sfix(16)  OutScaling=2^0
  miir : M-S-Function  Tag=miir  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  Constant/1 -> miir/1
  miir/1 -> Out1/1

== system ltpda_library/Methods/miir/Helper/get ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  get : M-S-Function  Tag=get  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> get/1
  get/1 -> Out1/1

== system ltpda_library/Methods/miir/Helper/isfield ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  isfield : M-S-Function  Tag=isfield  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> isfield/1
  isfield/1 -> Out1/1

== system ltpda_library/Methods/miir/Helper/isvalid ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  isvalid : M-S-Function  Tag=isvalid  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> isvalid/1
  isvalid/1 -> Out1/1

== system ltpda_library/Methods/miir/Helper/redesign ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  redesign : M-S-Function  Tag=redesign  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> redesign/1
  redesign/1 -> Out1/1

== system ltpda_library/Methods/miir/Helper/set ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  set : M-S-Function  Tag=set  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> set/1
  set/1 -> Out1/1

== system ltpda_library/Methods/miir/Output/char ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  char : M-S-Function  Tag=char  FunctionName=ltpdasim
  wires:
  char/1 -> Terminator/1
  In1/1 -> char/1

== system ltpda_library/Methods/miir/Output/display ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  display : M-S-Function  Tag=display  FunctionName=ltpdasim
  wires:
  display/1 -> Terminator/1
  In1/1 -> display/1

== system ltpda_library/Methods/miir/Output/save ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  save : M-S-Function  Tag=save  FunctionName=ltpdasim
  wires:
  save/1 -> Terminator/1
  In1/1 -> save/1

== system ltpda_library/Methods/miir/Output/string ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  string : M-S-Function  Tag=string  FunctionName=ltpdasim
  wires:
  string/1 -> Terminator/1
  In1/1 -> string/1

== system ltpda_library/Methods/miir/Relational Operator/eq ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  eq : M-S-Function  Tag=eq  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> eq/1
  eq/1 -> Out1/1

== system ltpda_library/Methods/miir/Relational Operator/ne ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  ne : M-S-Function  Tag=ne  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> ne/1
  ne/1 -> Out1/1

== system ltpda_library/Methods/miir/Signal Processing/resp ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  resp : M-S-Function  Tag=resp  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> resp/1
  resp/1 -> Out1/1

== system ltpda_library/Methods/param/Constructor/param ==
  Constant : Constant  OutDataType=sfix(16)  OutScaling=2^0
  param : M-S-Function  Tag=param  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  Constant/1 -> param/1
  param/1 -> Out1/1

== system ltpda_library/Methods/param/Helper/cat ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  cat : M-S-Function  Tag=cat  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> cat/1
  cat/1 -> Out1/1

== system ltpda_library/Methods/param/Helper/get ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  get : M-S-Function  Tag=get  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> get/1
  get/1 -> Out1/1

== system ltpda_library/Methods/param/Helper/isfield ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  isfield : M-S-Function  Tag=isfield  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> isfield/1
  isfield/1 -> Out1/1

== system ltpda_library/Methods/param/Helper/isvalid ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  isvalid : M-S-Function  Tag=isvalid  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> isvalid/1
  isvalid/1 -> Out1/1

== system ltpda_library/Methods/param/Helper/set ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  set : M-S-Function  Tag=set  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> set/1
  set/1 -> Out1/1

== system ltpda_library/Methods/param/Operator/mux ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  mux : M-S-Function  Tag=mux  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> mux/1
  mux/1 -> Out1/1

== system ltpda_library/Methods/param/Output/char ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  char : M-S-Function  Tag=char  FunctionName=ltpdasim
  wires:
  char/1 -> Terminator/1
  In1/1 -> char/1

== system ltpda_library/Methods/param/Output/display ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  display : M-S-Function  Tag=display  FunctionName=ltpdasim
  wires:
  display/1 -> Terminator/1
  In1/1 -> display/1

== system ltpda_library/Methods/param/Output/save ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  save : M-S-Function  Tag=save  FunctionName=ltpdasim
  wires:
  save/1 -> Terminator/1
  In1/1 -> save/1

== system ltpda_library/Methods/param/Output/string ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  string : M-S-Function  Tag=string  FunctionName=ltpdasim
  wires:
  string/1 -> Terminator/1
  In1/1 -> string/1

== system ltpda_library/Methods/param/Relational Operator/eq ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  eq : M-S-Function  Tag=eq  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> eq/1
  eq/1 -> Out1/1

== system ltpda_library/Methods/param/Relational Operator/ne ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  ne : M-S-Function  Tag=ne  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> ne/1
  ne/1 -> Out1/1

== system ltpda_library/Methods/plist/Constructor/plist ==
  Constant : Constant  OutDataType=sfix(16)  OutScaling=2^0
  plist : M-S-Function  Tag=plist  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  Constant/1 -> plist/1
  plist/1 -> Out1/1

== system ltpda_library/Methods/plist/Helper/append ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  append : M-S-Function  Tag=append  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> append/1
  append/1 -> Out1/1

== system ltpda_library/Methods/plist/Helper/combine ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  combine : M-S-Function  Tag=combine  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> combine/1
  combine/1 -> Out1/1

== system ltpda_library/Methods/plist/Helper/find ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  find : M-S-Function  Tag=find  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> find/1
  find/1 -> Out1/1

== system ltpda_library/Methods/plist/Helper/get ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  get : M-S-Function  Tag=get  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> get/1
  get/1 -> Out1/1

== system ltpda_library/Methods/plist/Helper/isfield ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  isfield : M-S-Function  Tag=isfield  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> isfield/1
  isfield/1 -> Out1/1

== system ltpda_library/Methods/plist/Helper/isparam ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  isparam : M-S-Function  Tag=isparam  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> isparam/1
  isparam/1 -> Out1/1

== system ltpda_library/Methods/plist/Helper/isvalid ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  isvalid : M-S-Function  Tag=isvalid  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> isvalid/1
  isvalid/1 -> Out1/1

== system ltpda_library/Methods/plist/Helper/nparams ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  nparams : M-S-Function  Tag=nparams  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> nparams/1
  nparams/1 -> Out1/1

== system ltpda_library/Methods/plist/Helper/pset ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  pset : M-S-Function  Tag=pset  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> pset/1
  pset/1 -> Out1/1

== system ltpda_library/Methods/plist/Helper/remove ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  remove : M-S-Function  Tag=remove  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> remove/1
  remove/1 -> Out1/1

== system ltpda_library/Methods/plist/Helper/set ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  set : M-S-Function  Tag=set  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> set/1
  set/1 -> Out1/1

== system ltpda_library/Methods/plist/Helper/string ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  string : M-S-Function  Tag=string  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> string/1
  string/1 -> Out1/1

== system ltpda_library/Methods/plist/Output/char ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  char : M-S-Function  Tag=char  FunctionName=ltpdasim
  wires:
  char/1 -> Terminator/1
  In1/1 -> char/1

== system ltpda_library/Methods/plist/Output/display ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  display : M-S-Function  Tag=display  FunctionName=ltpdasim
  wires:
  display/1 -> Terminator/1
  In1/1 -> display/1

== system ltpda_library/Methods/plist/Output/save ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  save : M-S-Function  Tag=save  FunctionName=ltpdasim
  wires:
  save/1 -> Terminator/1
  In1/1 -> save/1

== system ltpda_library/Methods/plist/Relational Operator/eq ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  eq : M-S-Function  Tag=eq  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> eq/1
  eq/1 -> Out1/1

== system ltpda_library/Methods/plist/Relational Operator/ne ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  ne : M-S-Function  Tag=ne  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> ne/1
  ne/1 -> Out1/1

== system ltpda_library/Methods/plist/Signal Processing/pzmresp ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  pzmresp : M-S-Function  Tag=pzmresp  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> pzmresp/1
  pzmresp/1 -> Out1/1

== system ltpda_library/Methods/plist/Signal Processing/resp ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  resp : M-S-Function  Tag=resp  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> resp/1
  resp/1 -> Out1/1

== system ltpda_library/Methods/pole/Constructor/pole ==
  Constant : Constant  OutDataType=sfix(16)  OutScaling=2^0
  pole : M-S-Function  Tag=pole  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  Constant/1 -> pole/1
  pole/1 -> Out1/1

== system ltpda_library/Methods/pole/Helper/cat ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  cat : M-S-Function  Tag=cat  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> cat/1
  cat/1 -> Out1/1

== system ltpda_library/Methods/pole/Helper/char ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  char : M-S-Function  Tag=char  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> char/1
  char/1 -> Out1/1

== system ltpda_library/Methods/pole/Helper/get ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  get : M-S-Function  Tag=get  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> get/1
  get/1 -> Out1/1

== system ltpda_library/Methods/pole/Helper/isfield ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  isfield : M-S-Function  Tag=isfield  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> isfield/1
  isfield/1 -> Out1/1

== system ltpda_library/Methods/pole/Helper/isvalid ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  isvalid : M-S-Function  Tag=isvalid  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> isvalid/1
  isvalid/1 -> Out1/1

== system ltpda_library/Methods/pole/Helper/set ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  set : M-S-Function  Tag=set  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> set/1
  set/1 -> Out1/1

== system ltpda_library/Methods/pole/Helper/string ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  string : M-S-Function  Tag=string  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> string/1
  string/1 -> Out1/1

== system ltpda_library/Methods/pole/Output/display ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  display : M-S-Function  Tag=display  FunctionName=ltpdasim
  wires:
  display/1 -> Terminator/1
  In1/1 -> display/1

== system ltpda_library/Methods/pole/Output/save ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  save : M-S-Function  Tag=save  FunctionName=ltpdasim
  wires:
  save/1 -> Terminator/1
  In1/1 -> save/1

== system ltpda_library/Methods/pole/Relational Operator/eq ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  eq : M-S-Function  Tag=eq  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> eq/1
  eq/1 -> Out1/1

== system ltpda_library/Methods/pole/Relational Operator/ne ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  ne : M-S-Function  Tag=ne  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> ne/1
  ne/1 -> Out1/1

== system ltpda_library/Methods/pole/Signal Processing/resp ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  resp : M-S-Function  Tag=resp  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> resp/1
  resp/1 -> Out1/1

== system ltpda_library/Methods/provenance/Constructor/provenance ==
  Constant : Constant  OutDataType=sfix(16)  OutScaling=2^0
  provenance : M-S-Function  Tag=provenance  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  Constant/1 -> provenance/1
  provenance/1 -> Out1/1

== system ltpda_library/Methods/provenance/Helper/get ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  get : M-S-Function  Tag=get  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> get/1
  get/1 -> Out1/1

== system ltpda_library/Methods/provenance/Helper/isfield ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  isfield : M-S-Function  Tag=isfield  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> isfield/1
  isfield/1 -> Out1/1

== system ltpda_library/Methods/provenance/Helper/isvalid ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  isvalid : M-S-Function  Tag=isvalid  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> isvalid/1
  isvalid/1 -> Out1/1

== system ltpda_library/Methods/provenance/Helper/set ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  set : M-S-Function  Tag=set  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> set/1
  set/1 -> Out1/1

== system ltpda_library/Methods/provenance/Output/char ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  char : M-S-Function  Tag=char  FunctionName=ltpdasim
  wires:
  char/1 -> Terminator/1
  In1/1 -> char/1

== system ltpda_library/Methods/provenance/Output/display ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  display : M-S-Function  Tag=display  FunctionName=ltpdasim
  wires:
  display/1 -> Terminator/1
  In1/1 -> display/1

== system ltpda_library/Methods/provenance/Output/save ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  save : M-S-Function  Tag=save  FunctionName=ltpdasim
  wires:
  save/1 -> Terminator/1
  In1/1 -> save/1

== system ltpda_library/Methods/provenance/Output/string ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  string : M-S-Function  Tag=string  FunctionName=ltpdasim
  wires:
  string/1 -> Terminator/1
  In1/1 -> string/1

== system ltpda_library/Methods/provenance/Relational Operator/eq ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  eq : M-S-Function  Tag=eq  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> eq/1
  eq/1 -> Out1/1

== system ltpda_library/Methods/provenance/Relational Operator/ne ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  ne : M-S-Function  Tag=ne  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> ne/1
  ne/1 -> Out1/1

== system ltpda_library/Methods/pzmodel/Constructor/pzmodel ==
  Constant : Constant  OutDataType=sfix(16)  OutScaling=2^0
  pzmodel : M-S-Function  Tag=pzmodel  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  Constant/1 -> pzmodel/1
  pzmodel/1 -> Out1/1
