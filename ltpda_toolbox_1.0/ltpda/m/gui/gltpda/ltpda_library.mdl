simulink library "ltpda_library"  (Simulink 7.1)
(part 3 of 3)

== system ltpda_library/Methods/pzmodel/Helper/get ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  get : M-S-Function  Tag=get  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> get/1
  get/1 -> Out1/1

== system ltpda_library/Methods/pzmodel/Helper/isfield ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  isfield : M-S-Function  Tag=isfield  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> isfield/1
  isfield/1 -> Out1/1

== system ltpda_library/Methods/pzmodel/Helper/isvalid ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  isvalid : M-S-Function  Tag=isvalid  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> isvalid/1
  isvalid/1 -> Out1/1

== system ltpda_library/Methods/pzmodel/Helper/set ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  set : M-S-Function  Tag=set  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> set/1
  set/1 -> Out1/1

== system ltpda_library/Methods/pzmodel/Helper/string ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  string : M-S-Function  Tag=string  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> string/1
  string/1 -> Out1/1

== system ltpda_library/Methods/pzmodel/Operator/tomfir ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  tomfir : M-S-Function  Tag=tomfir  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> tomfir/1
  tomfir/1 -> Out1/1

== system ltpda_library/Methods/pzmodel/Operator/tomiir ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  tomiir : M-S-Function  Tag=tomiir  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> tomiir/1
  tomiir/1 -> Out1/1

== system ltpda_library/Methods/pzmodel/Output/char ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  char : M-S-Function  Tag=char  FunctionName=ltpdasim
  wires:
  char/1 -> Terminator/1
  In1/1 -> char/1

== system ltpda_library/Methods/pzmodel/Output/display ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  display : M-S-Function  Tag=display  FunctionName=ltpdasim
  wires:
  display/1 -> Terminator/1
  In1/1 -> display/1

== system ltpda_library/Methods/pzmodel/Output/save ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  save : M-S-Function  Tag=save  FunctionName=ltpdasim
  wires:
  save/1 -> Terminator/1
  In1/1 -> save/1

== system ltpda_library/Methods/pzmodel/Relational Operator/eq ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  eq : M-S-Function  Tag=eq  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> eq/1
  eq/1 -> Out1/1

== system ltpda_library/Methods/pzmodel/Relational Operator/ne ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  ne : M-S-Function  Tag=ne  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> ne/1
  ne/1 -> Out1/1

== system ltpda_library/Methods/pzmodel/Signal Processing/resp ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  resp : M-S-Function  Tag=resp  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> resp/1
  resp/1 -> Out1/1

== system ltpda_library/Methods/specwin/Constructor/specwin ==
  Constant : Constant  OutDataType=sfix(16)  OutScaling=2^0
  specwin : M-S-Function  Tag=specwin  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  Constant/1 -> specwin/1
  specwin/1 -> Out1/1

== system ltpda_library/Methods/specwin/Helper/get ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  get : M-S-Function  Tag=get  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> get/1
  get/1 -> Out1/1

== system ltpda_library/Methods/specwin/Helper/isfield ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  isfield : M-S-Function  Tag=isfield  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> isfield/1
  isfield/1 -> Out1/1

== system ltpda_library/Methods/specwin/Helper/isvalid ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  isvalid : M-S-Function  Tag=isvalid  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> isvalid/1
  isvalid/1 -> Out1/1

== system ltpda_library/Methods/specwin/Helper/set ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  set : M-S-Function  Tag=set  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> set/1
  set/1 -> Out1/1

== system ltpda_library/Methods/specwin/Helper/string ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  string : M-S-Function  Tag=string  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> string/1
  string/1 -> Out1/1

== system ltpda_library/Methods/specwin/Output/char ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  char : M-S-Function  Tag=char  FunctionName=ltpdasim
  wires:
  char/1 -> Terminator/1
  In1/1 -> char/1

== system ltpda_library/Methods/specwin/Output/display ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  display : M-S-Function  Tag=display  FunctionName=ltpdasim
  wires:
  display/1 -> Terminator/1
  In1/1 -> display/1

== system ltpda_library/Methods/specwin/Output/plot ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  plot : M-S-Function  Tag=plot  FunctionName=ltpdasim
  wires:
  plot/1 -> Terminator/1
  In1/1 -> plot/1

== system ltpda_library/Methods/specwin/Output/save ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  save : M-S-Function  Tag=save  FunctionName=ltpdasim
  wires:
  save/1 -> Terminator/1
  In1/1 -> save/1

== system ltpda_library/Methods/specwin/Relational Operator/eq ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  eq : M-S-Function  Tag=eq  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> eq/1
  eq/1 -> Out1/1

== system ltpda_library/Methods/specwin/Relational Operator/ne ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  ne : M-S-Function  Tag=ne  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> ne/1
  ne/1 -> Out1/1

== system ltpda_library/Methods/time/Arithmetic Operator/minus ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  minus : M-S-Function  Tag=minus  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> minus/1
  minus/1 -> Out1/1

== system ltpda_library/Methods/time/Arithmetic Operator/plus ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  plus : M-S-Function  Tag=plus  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> plus/1
  plus/1 -> Out1/1

== system ltpda_library/Methods/time/Constructor/time ==
  Constant : Constant  OutDataType=sfix(16)  OutScaling=2^0
  time : M-S-Function  Tag=time  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  Constant/1 -> time/1
  time/1 -> Out1/1

== system ltpda_library/Methods/time/Helper/get ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  get : M-S-Function  Tag=get  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> get/1
  get/1 -> Out1/1

== system ltpda_library/Methods/time/Helper/isfield ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  isfield : M-S-Function  Tag=isfield  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> isfield/1
  isfield/1 -> Out1/1

== system ltpda_library/Methods/time/Helper/isvalid ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  isvalid : M-S-Function  Tag=isvalid  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> isvalid/1
  isvalid/1 -> Out1/1

== system ltpda_library/Methods/time/Helper/set ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  set : M-S-Function  Tag=set  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> set/1
  set/1 -> Out1/1

== system ltpda_library/Methods/time/Helper/string ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  string : M-S-Function  Tag=string  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> string/1
  string/1 -> Out1/1

== system ltpda_library/Methods/time/Output/char ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  char : M-S-Function  Tag=char  FunctionName=ltpdasim
  wires:
  char/1 -> Terminator/1
  In1/1 -> char/1

== system ltpda_library/Methods/time/Output/display ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  display : M-S-Function  Tag=display  FunctionName=ltpdasim
  wires:
  display/1 -> Terminator/1
  In1/1 -> display/1

== system ltpda_library/Methods/time/Output/format ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  format : M-S-Function  Tag=format  FunctionName=ltpdasim
  wires:
  format/1 -> Terminator/1
  In1/1 -> format/1

== system ltpda_library/Methods/time/Output/save ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  save : M-S-Function  Tag=save  FunctionName=ltpdasim
  wires:
  save/1 -> Terminator/1
  In1/1 -> save/1

== system ltpda_library/Methods/time/Relational Operator/eq ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  eq : M-S-Function  Tag=eq  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> eq/1
  eq/1 -> Out1/1

== system ltpda_library/Methods/time/Relational Operator/ne ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  ne : M-S-Function  Tag=ne  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> ne/1
  ne/1 -> Out1/1

== system ltpda_library/Methods/timeformat/Constructor/timeformat ==
  Constant : Constant  OutDataType=sfix(16)  OutScaling=2^0
  timeformat : M-S-Function  Tag=timeformat  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  Constant/1 -> timeformat/1
  timeformat/1 -> Out1/1

== system ltpda_library/Methods/timeformat/Helper/get ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  get : M-S-Function  Tag=get  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> get/1
  get/1 -> Out1/1

== system ltpda_library/Methods/timeformat/Helper/isfield ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  isfield : M-S-Function  Tag=isfield  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> isfield/1
  isfield/1 -> Out1/1

== system ltpda_library/Methods/timeformat/Helper/isvalid ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  isvalid : M-S-Function  Tag=isvalid  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> isvalid/1
  isvalid/1 -> Out1/1

== system ltpda_library/Methods/timeformat/Helper/set ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  set : M-S-Function  Tag=set  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> set/1
  set/1 -> Out1/1

== system ltpda_library/Methods/timeformat/Output/char ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  char : M-S-Function  Tag=char  FunctionName=ltpdasim
  wires:
  char/1 -> Terminator/1
  In1/1 -> char/1

== system ltpda_library/Methods/timeformat/Output/display ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  display : M-S-Function  Tag=display  FunctionName=ltpdasim
  wires:
  display/1 -> Terminator/1
  In1/1 -> display/1

== system ltpda_library/Methods/timeformat/Output/save ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  save : M-S-Function  Tag=save  FunctionName=ltpdasim
  wires:
  save/1 -> Terminator/1
  In1/1 -> save/1

== system ltpda_library/Methods/timeformat/Output/string ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  string : M-S-Function  Tag=string  FunctionName=ltpdasim
  wires:
  string/1 -> Terminator/1
  In1/1 -> string/1

== system ltpda_library/Methods/timeformat/Relational Operator/eq ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  eq : M-S-Function  Tag=eq  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> eq/1
  eq/1 -> Out1/1

== system ltpda_library/Methods/timeformat/Relational Operator/ne ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  ne : M-S-Function  Tag=ne  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> ne/1
  ne/1 -> Out1/1

== system ltpda_library/Methods/timespan/Constructor/timespan ==
  Constant : Constant  OutDataType=sfix(16)  OutScaling=2^0
  timespan : M-S-Function  Tag=timespan  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  Constant/1 -> timespan/1
  timespan/1 -> Out1/1

== system ltpda_library/Methods/timespan/Helper/get ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  get : M-S-Function  Tag=get  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> get/1
  get/1 -> Out1/1

== system ltpda_library/Methods/timespan/Helper/isfield ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  isfield : M-S-Function  Tag=isfield  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> isfield/1
  isfield/1 -> Out1/1

== system ltpda_library/Methods/timespan/Helper/isvalid ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  isvalid : M-S-Function  Tag=isvalid  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> isvalid/1
  isvalid/1 -> Out1/1

== system ltpda_library/Methods/timespan/Helper/set ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  set : M-S-Function  Tag=set  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> set/1
  set/1 -> Out1/1

== system ltpda_library/Methods/timespan/Output/char ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  char : M-S-Function  Tag=char  FunctionName=ltpdasim
  wires:
  char/1 -> Terminator/1
  In1/1 -> char/1

== system ltpda_library/Methods/timespan/Output/display ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  display : M-S-Function  Tag=display  FunctionName=ltpdasim
  wires:
  display/1 -> Terminator/1
  In1/1 -> display/1

== system ltpda_library/Methods/timespan/Output/save ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  save : M-S-Function  Tag=save  FunctionName=ltpdasim
  wires:
  save/1 -> Terminator/1
  In1/1 -> save/1

== system ltpda_library/Methods/timespan/Output/string ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  string : M-S-Function  Tag=string  FunctionName=ltpdasim
  wires:
  string/1 -> Terminator/1
  In1/1 -> string/1

== system ltpda_library/Methods/timespan/Relational Operator/eq ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  eq : M-S-Function  Tag=eq  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> eq/1
  eq/1 -> Out1/1

== system ltpda_library/Methods/timespan/Relational Operator/ne ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  ne : M-S-Function  Tag=ne  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> ne/1
  ne/1 -> Out1/1

== system ltpda_library/Methods/tsdata/Constructor/tsdata ==
  Constant : Constant  OutDataType=sfix(16)  OutScaling=2^0
  tsdata : M-S-Function  Tag=tsdata  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  Constant/1 -> tsdata/1
  tsdata/1 -> Out1/1

== system ltpda_library/Methods/tsdata/Helper/get ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  get : M-S-Function  Tag=get  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> get/1
  get/1 -> Out1/1

== system ltpda_library/Methods/tsdata/Helper/isfield ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  isfield : M-S-Function  Tag=isfield  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> isfield/1
  isfield/1 -> Out1/1

== system ltpda_library/Methods/tsdata/Helper/isvalid ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  isvalid : M-S-Function  Tag=isvalid  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> isvalid/1
  isvalid/1 -> Out1/1

== system ltpda_library/Methods/tsdata/Helper/set ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  set : M-S-Function  Tag=set  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> set/1
  set/1 -> Out1/1

== system ltpda_library/Methods/tsdata/Output/char ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  char : M-S-Function  Tag=char  FunctionName=ltpdasim
  wires:
  char/1 -> Terminator/1
  In1/1 -> char/1

== system ltpda_library/Methods/tsdata/Output/display ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  display : M-S-Function  Tag=display  FunctionName=ltpdasim
  wires:
  display/1 -> Terminator/1
  In1/1 -> display/1

== system ltpda_library/Methods/tsdata/Output/save ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  save : M-S-Function  Tag=save  FunctionName=ltpdasim
  wires:
  save/1 -> Terminator/1
  In1/1 -> save/1

== system ltpda_library/Methods/tsdata/Relational Operator/eq ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  eq : M-S-Function  Tag=eq  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> eq/1
  eq/1 -> Out1/1

== system ltpda_library/Methods/tsdata/Relational Operator/ne ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  ne : M-S-Function  Tag=ne  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> ne/1
  ne/1 -> Out1/1

== system ltpda_library/Methods/xydata/Constructor/xydata ==
  Constant : Constant  OutDataType=sfix(16)  OutScaling=2^0
  xydata : M-S-Function  Tag=xydata  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  Constant/1 -> xydata/1
  xydata/1 -> Out1/1

== system ltpda_library/Methods/xydata/Helper/get ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  get : M-S-Function  Tag=get  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> get/1
  get/1 -> Out1/1

== system ltpda_library/Methods/xydata/Helper/isfield ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  isfield : M-S-Function  Tag=isfield  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> isfield/1
  isfield/1 -> Out1/1

== system ltpda_library/Methods/xydata/Helper/isvalid ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  isvalid : M-S-Function  Tag=isvalid  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> isvalid/1
  isvalid/1 -> Out1/1

== system ltpda_library/Methods/xydata/Helper/set ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  set : M-S-Function  Tag=set  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> set/1
  set/1 -> Out1/1

== system ltpda_library/Methods/xydata/Output/char ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  char : M-S-Function  Tag=char  FunctionName=ltpdasim
  wires:
  char/1 -> Terminator/1
  In1/1 -> char/1

== system ltpda_library/Methods/xydata/Output/display ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  display : M-S-Function  Tag=display  FunctionName=ltpdasim
  wires:
  display/1 -> Terminator/1
  In1/1 -> display/1

== system ltpda_library/Methods/xydata/Output/save ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  save : M-S-Function  Tag=save  FunctionName=ltpdasim
  wires:
  save/1 -> Terminator/1
  In1/1 -> save/1

== system ltpda_library/Methods/xydata/Relational Operator/eq ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  eq : M-S-Function  Tag=eq  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> eq/1
  eq/1 -> Out1/1

== system ltpda_library/Methods/xydata/Relational Operator/ne ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  ne : M-S-Function  Tag=ne  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> ne/1
  ne/1 -> Out1/1

== system ltpda_library/Methods/xyzdata/Constructor/xyzdata ==
  Constant : Constant  OutDataType=sfix(16)  OutScaling=2^0
  xyzdata : M-S-Function  Tag=xyzdata  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  Constant/1 -> xyzdata/1
  xyzdata/1 -> Out1/1

== system ltpda_library/Methods/xyzdata/Helper/get ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  get : M-S-Function  Tag=get  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> get/1
  get/1 -> Out1/1

== system ltpda_library/Methods/xyzdata/Helper/isfield ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  isfield : M-S-Function  Tag=isfield  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> isfield/1
  isfield/1 -> Out1/1

== system ltpda_library/Methods/xyzdata/Helper/isvalid ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  isvalid : M-S-Function  Tag=isvalid  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> isvalid/1
  isvalid/1 -> Out1/1

== system ltpda_library/Methods/xyzdata/Helper/set ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  set : M-S-Function  Tag=set  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> set/1
  set/1 -> Out1/1

== system ltpda_library/Methods/xyzdata/Output/display ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  display : M-S-Function  Tag=display  FunctionName=ltpdasim
  wires:
  display/1 -> Terminator/1
  In1/1 -> display/1

== system ltpda_library/Methods/xyzdata/Output/save ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  save : M-S-Function  Tag=save  FunctionName=ltpdasim
  wires:
  save/1 -> Terminator/1
  In1/1 -> save/1

== system ltpda_library/Methods/xyzdata/Relational Operator/eq ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  eq : M-S-Function  Tag=eq  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> eq/1
  eq/1 -> Out1/1

== system ltpda_library/Methods/xyzdata/Relational Operator/ne ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  ne : M-S-Function  Tag=ne  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> ne/1
  ne/1 -> Out1/1

== system ltpda_library/Methods/zero/Constructor/zero ==
  Constant : Constant  OutDataType=sfix(16)  OutScaling=2^0
  zero : M-S-Function  Tag=zero  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  Constant/1 -> zero/1
  zero/1 -> Out1/1

== system ltpda_library/Methods/zero/Helper/cat ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  cat : M-S-Function  Tag=cat  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> cat/1
  cat/1 -> Out1/1

== system ltpda_library/Methods/zero/Helper/get ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  get : M-S-Function  Tag=get  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> get/1
  get/1 -> Out1/1

== system ltpda_library/Methods/zero/Helper/isfield ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  isfield : M-S-Function  Tag=isfield  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> isfield/1
  isfield/1 -> Out1/1

== system ltpda_library/Methods/zero/Helper/isvalid ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  isvalid : M-S-Function  Tag=isvalid  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> isvalid/1
  isvalid/1 -> Out1/1

== system ltpda_library/Methods/zero/Helper/set ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  set : M-S-Function  Tag=set  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> set/1
  set/1 -> Out1/1

== system ltpda_library/Methods/zero/Helper/string ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  string : M-S-Function  Tag=string  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> string/1
  string/1 -> Out1/1

== system ltpda_library/Methods/zero/Output/char ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  char : M-S-Function  Tag=char  FunctionName=ltpdasim
  wires:
  char/1 -> Terminator/1
  In1/1 -> char/1

== system ltpda_library/Methods/zero/Output/display ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  display : M-S-Function  Tag=display  FunctionName=ltpdasim
  wires:
  display/1 -> Terminator/1
  In1/1 -> display/1

== system ltpda_library/Methods/zero/Output/save ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Terminator : Terminator
  save : M-S-Function  Tag=save  FunctionName=ltpdasim
  wires:
  save/1 -> Terminator/1
  In1/1 -> save/1

== system ltpda_library/Methods/zero/Relational Operator/eq ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  eq : M-S-Function  Tag=eq  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> eq/1
  eq/1 -> Out1/1

== system ltpda_library/Methods/zero/Relational Operator/ne ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  ne : M-S-Function  Tag=ne  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> ne/1
  ne/1 -> Out1/1

== system ltpda_library/Methods/zero/Signal Processing/resp ==
  In1 : Inport  OutDataType=sfix(16)  OutScaling=2^0
  resp : M-S-Function  Tag=resp  FunctionName=ltpdasim
  Out1 : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  In1/1 -> resp/1
  resp/1 -> Out1/1
